# Keil uVision project project name.uvproj, settings and files
target <project name> (MCS-51)
  device: SC92F8003 SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF)  XRAM(0-0xFF) CLOCK(16000000)
  output: project name +hex
  c flags: Optimize=8
  c define: SC92Fx41xB
  c include: ..\FWLib\SC92F_Lib\inc;..\User
  link misc: REMOVEUNUSED
  group User
    ../User/: main.c SC_Init.c SC_it.c SysFunVarDefine.c CompCtrlDefine.c CallBackFunction.c
  group FWLib
    ../FWLib/SC92F_Lib/src/: sc92f_gpio.c sc92f_option.c
  group Startup
    ./: STARTUP.A51
