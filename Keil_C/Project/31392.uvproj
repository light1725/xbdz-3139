# Keil uVision project 31392.uvproj, settings and files
target 31392 (MCS-51)
  device: SC92F8411B SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF)  XRAM(0-0xFF) CLOCK(16000000)
  output: 31392 +hex
  c flags: Optimize=8
  c define: SC92Fx41xB
  c include: ..\FWLib\SC92F_Lib\inc;..\User
  link misc: REMOVEUNUSED
  group User
    ../User/: main.c SC_Init.c SC_it.c SysFunVarDefine.c CompCtrlDefine.c CallBackFunction.c BSP.c HostControl.c SC92F8X1XB_HighSensitive_lib_T1_L_V2.2.0.LIB TKDriver.c
  group FWLib
    ../FWLib/SC92F_Lib/src/: sc92f_gpio.c sc92f_option.c
  group Startup
    ./: STARTUP.A51
